v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {schematics/add/ALU.sym} 90 0 0 0 {name=x1}
C {gnd.sym} -60 -340 1 0 {name=l1 lab=GND}
C {gnd.sym} -60 -320 1 0 {name=l2 lab=GND}
C {gnd.sym} -60 340 0 0 {name=l3 lab=GND}
C {ipin.sym} -60 -300 0 0 {name=p6 lab=A0}
C {ipin.sym} -60 -280 0 0 {name=p1 lab=A4}
C {ipin.sym} -60 -260 0 0 {name=p2 lab=A12}
C {ipin.sym} -60 -240 0 0 {name=p3 lab=A8}
C {ipin.sym} -60 -220 0 0 {name=p4 lab=B4}
C {ipin.sym} -60 -200 0 0 {name=p5 lab=B0}
C {ipin.sym} -60 -180 0 0 {name=p7 lab=B12}
C {ipin.sym} -60 -160 0 0 {name=p8 lab=B8}
C {ipin.sym} -60 -140 0 0 {name=p9 lab=A1}
C {ipin.sym} -60 -120 0 0 {name=p10 lab=A13}
C {ipin.sym} -60 -100 0 0 {name=p11 lab=A5}
C {ipin.sym} -60 -80 0 0 {name=p12 lab=A9}
C {ipin.sym} -60 -60 0 0 {name=p13 lab=B5}
C {ipin.sym} -60 -40 0 0 {name=p14 lab=B1}
C {ipin.sym} -60 -20 0 0 {name=p15 lab=B13}
C {ipin.sym} -60 0 0 0 {name=p16 lab=B9}
C {ipin.sym} -60 20 0 0 {name=p17 lab=A14}
C {ipin.sym} -60 40 0 0 {name=p18 lab=A6}
C {ipin.sym} -60 60 0 0 {name=p19 lab=A2}
C {ipin.sym} -60 80 0 0 {name=p20 lab=A10}
C {ipin.sym} -60 100 0 0 {name=p21 lab=B14}
C {ipin.sym} -60 120 0 0 {name=p22 lab=B6}
C {ipin.sym} -60 140 0 0 {name=p23 lab=B2}
C {ipin.sym} -60 160 0 0 {name=p24 lab=B10}
C {ipin.sym} -60 180 0 0 {name=p25 lab=A7}
C {ipin.sym} -60 200 0 0 {name=p26 lab=A15}
C {ipin.sym} -60 220 0 0 {name=p27 lab=A3}
C {ipin.sym} -60 240 0 0 {name=p28 lab=A11}
C {ipin.sym} -60 260 0 0 {name=p29 lab=B7}
C {ipin.sym} -60 280 0 0 {name=p30 lab=B15}
C {ipin.sym} -60 300 0 0 {name=p31 lab=B3}
C {ipin.sym} -60 320 0 0 {name=p32 lab=B11}
C {opin.sym} 240 -320 0 0 {name=p33 lab=Y4}
C {opin.sym} 240 -300 0 0 {name=p34 lab=Y8}
C {opin.sym} 240 -280 0 0 {name=p35 lab=Y12}
C {opin.sym} 240 -260 0 0 {name=p36 lab=Y0}
C {opin.sym} 240 -240 0 0 {name=p37 lab=Y5}
C {opin.sym} 240 -220 0 0 {name=p38 lab=Y9}
C {opin.sym} 240 -200 0 0 {name=p39 lab=Y1}
C {opin.sym} 240 -180 0 0 {name=p40 lab=Y13}
C {opin.sym} 240 -160 0 0 {name=p41 lab=Y10}
C {opin.sym} 240 -120 0 0 {name=p42 lab=Y2}
C {opin.sym} 240 -100 0 0 {name=p43 lab=Y14}
C {opin.sym} 240 -80 0 0 {name=p44 lab=Y6}
C {opin.sym} 240 -60 0 0 {name=p45 lab=Y11}
C {opin.sym} 240 -40 0 0 {name=p46 lab=Y15}
C {opin.sym} 240 -20 0 0 {name=p47 lab=Y7}
C {opin.sym} 240 0 0 0 {name=p48 lab=Y3}
