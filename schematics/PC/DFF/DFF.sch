v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 70 -0 90 0 {lab=#net1}
N 60 0 70 -0 {lab=#net1}
N 175 -0 195 0 {lab=#net2}
N 290 -0 330 0 {lab=#net3}
N 450 10 480 10 {lab=#net4}
N 560 130 590 130 {lab=#net5}
N 470 130 480 130 {lab=#net4}
N 470 -90 470 -30 {lab=#net4}
N 310 -90 390 -90 {lab=#net3}
N 310 -90 310 -0 {lab=#net3}
N 190 -120 190 -0 {lab=#net2}
N 470 -30 470 10 {lab=#net4}
N 470 10 470 130 {lab=#net4}
N 60 -130 70 -130 {lab=#net6}
N 80 140 120 140 {lab=cbar}
N 195 140 205 140 {lab=c}
N 140 -190 140 -180 {lab=vdd}
N 510 -25 510 -20 {lab=vdd}
N 510 95 510 100 {lab=vdd}
N 620 95 620 100 {lab=vdd}
N 120 -35 120 -30 {lab=vdd}
N 30 175 30 185 {lab=vss}
N 30 170 30 175 {lab=vss}
N 30 185 30 210 {lab=vss}
N 140 170 140 205 {lab=vss}
N 510 160 510 170 {lab=vss}
N 620 165 620 170 {lab=vss}
N 620 160 620 165 {lab=vss}
N 510 40 510 45 {lab=vss}
N 120 30 120 35 {lab=vss}
N 55 -130 65 -130 {lab=#net6}
N -45 -130 -45 -75 {lab=#net1}
N -45 -75 70 -75 {lab=#net1}
N 70 -75 70 0 {lab=#net1}
N 455 -10 455 10 {lab=#net4}
C {opin.sym} 675 130 0 0 {name=p1 lab=Qb}
C {opin.sym} 565 10 0 0 {name=p2 lab=Q}
C {ipin.sym} -20 0 0 0 {name=p3 lab=D}
C {ipin.sym} 190 -140 2 0 {name=p4 lab=RSTn}
C {lab_wire.sym} 100 140 0 0 {name=p5 sig_type=std_logic lab=cbar}
C {lab_wire.sym} 205 140 0 0 {name=p6 sig_type=std_logic lab=c}
C {lab_wire.sym} 190 -140 0 0 {name=p7 sig_type=std_logic lab=RSTn}
C {lab_wire.sym} 330 -20 0 0 {name=p8 sig_type=std_logic lab=RSTn}
C {iopin.sym} 140 -190 3 0 {name=p9 lab=vdd}
C {lab_wire.sym} 140 -185 0 0 {name=p10 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 450 -130 0 0 {name=p11 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 510 -25 0 0 {name=p12 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 620 95 0 0 {name=p13 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 510 95 0 0 {name=p14 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 380 -60 0 0 {name=p15 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 215 40 0 0 {name=p16 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 120 -35 0 0 {name=p17 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 0 -40 0 0 {name=p18 sig_type=std_logic lab=vdd}
C {iopin.sym} 30 210 1 0 {name=p19 lab=vss}
C {lab_wire.sym} 30 205 0 0 {name=p20 sig_type=std_logic lab=vss}
C {lab_wire.sym} 140 205 0 0 {name=p21 sig_type=std_logic lab=vss}
C {lab_wire.sym} 510 170 0 0 {name=p22 sig_type=std_logic lab=vss}
C {lab_wire.sym} 620 170 0 0 {name=p23 sig_type=std_logic lab=vss}
C {lab_wire.sym} 510 45 0 0 {name=p24 sig_type=std_logic lab=vss}
C {lab_wire.sym} 380 40 0 0 {name=p25 sig_type=std_logic lab=vss}
C {lab_wire.sym} 275 -40 0 0 {name=p26 sig_type=std_logic lab=vss}
C {lab_wire.sym} 120 35 0 0 {name=p27 sig_type=std_logic lab=vss}
C {lab_wire.sym} 0 40 0 0 {name=p28 sig_type=std_logic lab=vss}
C {lab_wire.sym} 140 -80 0 0 {name=p29 sig_type=std_logic lab=vss}
C {lab_wire.sym} 450 -50 0 0 {name=p30 sig_type=std_logic lab=vss}
C {lab_wire.sym} 15 -35 0 0 {name=p31 sig_type=std_logic lab=c}
C {lab_wire.sym} 245 20 0 0 {name=p32 sig_type=std_logic lab=c}
C {lab_wire.sym} 435 -125 0 0 {name=p33 sig_type=std_logic lab=c}
C {lab_wire.sym} -25 -90 0 0 {name=p34 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 35 -170 0 0 {name=p35 sig_type=std_logic lab=vss}
C {lab_wire.sym} 5 -110 0 0 {name=p36 sig_type=std_logic lab=c}
C {lab_wire.sym} 15 30 0 0 {name=p37 sig_type=std_logic lab=cbar}
C {lab_wire.sym} 245 -25 0 0 {name=p38 sig_type=std_logic lab=cbar}
C {lab_wire.sym} 435 -60 0 0 {name=p39 sig_type=std_logic lab=cbar}
C {lab_wire.sym} 5 -155 0 0 {name=p40 sig_type=std_logic lab=cbar}
C {ipin.sym} 0 140 0 0 {name=p41 lab=CLK}
C {lab_wire.sym} 30 107.5 0 0 {name=p42 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 140 107.5 0 0 {name=p43 sig_type=std_logic lab=vdd}
C {schematics/PC/TG/TG.sym} 5 -130 0 0 {name=x13}
C {schematics/PC/TG/TG.sym} 245 0 0 0 {name=x12}
C {schematics/PC/TSI/TSI.sym} 0 20 0 0 {name=x3}
C {schematics/PC/TSI/TSI.sym} 450 -70 0 1 {name=x1}
C {schematics/PC/INV/inv_pc.sym} 20 160 0 0 {name=x2}
C {schematics/PC/INV/inv_pc.sym} 130 160 0 0 {name=x4}
C {schematics/PC/INV/inv_pc.sym} 500 150 0 0 {name=x7}
C {schematics/PC/INV/inv_pc.sym} 610 150 0 0 {name=x8}
C {schematics/PC/INV/inv_pc.sym} 110 20 0 0 {name=x9}
C {schematics/PC/INV/inv_pc.sym} 500 30 0 0 {name=x6}
C {schematics/PC/NAND2/NAND2.sym} 350 20 0 0 {name=x5}
C {schematics/PC/NAND2/NAND2.sym} 170 -100 0 1 {name=x10}
